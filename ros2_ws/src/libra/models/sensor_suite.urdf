Commit message: simplifications

File: ros2_ws/src/libra/models/sensor_suite.urdf (robot description, URDF)
Before this commit: robot sensor_suites, 5 links, 4 joints
Links:
- link camera_link: mass 0.066 -> None
- link lidar_link: mass 0.370 -> None
